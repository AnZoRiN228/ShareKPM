# Keil uVision project KPM_Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KPM_Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c limits.h initDevice.h ADC.c initDevice.c RCC.c GPIO.c USART.c NVIC_Settings.c DMA_Settings.c limits.c I2C.c ssd1306.c fonts.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
